<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PSS48.ewp</path>
    </project>
    <batchBuild />
</workspace>
